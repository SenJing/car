# Keil uVision project PWM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\PWM;..\USER;..\HARDWARE\KEY;..\HARDWARE\I2C;..\HARDWARE\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ./: control.c huidu.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/I2C/: i2c.c
    ../HARDWARE/MPU6050/: mpu6050.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group README
    ../: README.TXT
